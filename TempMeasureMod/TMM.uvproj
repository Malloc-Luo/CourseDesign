# Keil uVision project TMM.uvproj, settings and files
target TMM (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TMM
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group sys
    ./: STARTUP.A51
  group src
    ./src/: main.c bluetooth.c schedul.c ADtemp.c LEDdisplay.c ctrltemp.c
